/**
Curso de Arduino Intermediário disponibilizadas pela Equipe de robótica TERA
Simulação: https://wokwi.com/projects/349138115372253779
Venha nos conhecer no instagram: @roboticatera
**/
#include <IRremote.h>

const int pinoReceptor = 7;
decode_results resultados;
IRrecv irrecv(pinoReceptor);

const int pinoLed = 6;

void setup() {
  // put your setup code here, to run once:
  Serial.begin(9600);
  pinMode(pinoLed, OUTPUT);

  irrecv.enableIRIn();
}

void loop() {

  //Como encontror os valores hexadecimais de cada comando do controle
  if (irrecv.decode(&resultados)){
  Serial.println(resultados.value, HEX); 
  delay(100);
  irrecv.resume();
  }
  // Apertando a tecla 1
  if (resultados.value == 0xFF0CF3){
    digitalWrite(pinoLed, HIGH);
  }
  // Apertando a tecla 2
  if (resultados.value == 0xFF18E7){
    digitalWrite(pinoLed, HIGH);
    delay(500);
    digitalWrite(pinoLed, LOW);
    delay(500);
  }
  // Apertando a tecla 3
  if (resultados.value == 0xFF5EA1){
    digitalWrite(pinoLed, HIGH);
    delay(100);
    digitalWrite(pinoLed, LOW);
    delay(100);
  }
  // Apertando 0
  if(resultados.value == 0xFF16E9){
    digitalWrite(pinoLed, LOW);
  }

}
/**
%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%
%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%
%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%
%%$%M®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®33J33
%%$%M®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®3JJ33
%$$%M®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®33J33
%%$$®®®®®®®®®®5==(==(((¦¦¦¦!*!!!!*!!!¦¦!¦¦¦(((®®®®®(¦((¦((¦¦¦!!*!***!¦!!¦¦¦¦¦(((===®®®®®®®®®®®®J3J33
%%$$M®®®®®®®®®®®@===(¦(¦¦¦!¦!!*!!!!!!¦¦¦¦¦¦((¦®®®®®(¦(((((¦¦¦!!!!****¦!¦¦¦¦((((((M®®®®®®®®®®®®®J3J33
%$$%M®®®®®®®®®®®®®®==¦(¦¦¦¦¦*!!!!*¦!!¦¦¦¦!¦(((®®®®®(¦((((((¦¦!!!!**!!¦!!¦¦¦(¦((®®®®®®®®®®®®®®®®J3J33
%%$%M®®®®®®®®®®®®®®®®J(¦¦¦¦!*!!!!*¦!!¦¦¦¦¦¦(((®®®®®(¦((¦(((¦¦!!!!!*!!!!!¦¦¦(%®®®®®®®®®®®®®®®®®®33J33
%%$$M®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®!¦¦¦¦(((®®®®®(((((¦((¦®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®33J33
%%$%M®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®!¦¦¦¦(((®®®®®((((((((¦®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®J3J3P
%%$%®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®*¦¦¦¦(((®®®®®((((((((!®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®J3J3A
%$$%®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®*¦¦¦¦(((®®®®®((¦=((((¦®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®JJJ3Ç
$%$%M®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®!¦¦¦¦(((®®®®®(((((((¦¦®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®J3J3O
%$$%M®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®*¦¦¦((((®®®®®(((=((((=®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®33J3C
%$$%M®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®*¦¦¦((((®®®®®((((((((=®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®33J3A
%$$$®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®*¦¦¦((((®®®®®(((((¦((=®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®33J33
%%$%®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®*¦¦¦((((®®®®®((((((((=®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®3333S
%$$%M®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®!¦¦¦¦(((®®®®®((((((((=®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®33J3U
%$$%M®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®*¦¦¦((((®®®®®((((((((=®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®3333P
%$$%M®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®!¦¦¦¦(((®®®®®((((((((=®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®33J3R
%$$%®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®!¦¦¦((((®®®®®((((((((=®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®33J3E
%$$%M®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®!¦(¦((((®®®®®((((((((=®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®33J3M
%$3$®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®!¦¦¦((((®®®®®(((=((((=®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®33J3A
%%3$®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®!¦¦¦((==®®®®®(((=((((=®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®33J3C
$%$%®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®¦¦¦¦¦(((®®®®®(((=((((=®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®33J3Y
%%$$®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®!¦¦¦((((®®®®®((((((((=®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®33J3$
$$$%®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®¦¦¦(((((®®®®®(((=((((=®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®33J3$
$$$$M®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®¦¦¦¦((=(®®®®®=((=((((=®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®33J33
%%3%®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®MMMMMMMM®®®®®MMMMMMMMM®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®33J$$
$$$$M®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®33J33
$%$$M®®®®®®®®®®®M===(===((=C®®®®A(¦¦¦¦¦¦¦¦A®®®®®®M***!**!!!¦®®®®®®®®®®®®M!(®®®®®®®®®®®®®®®®®®®®33J3$
%%$$M®®®®®®®®®®®®®®®®C=®®®®®®®®®A¦®®®®®®®®®®®®®®®M*®®®®®®®®(¦®®®®®®®®®®M¦(((®®®®®®®®®®®®®®®®®®®3333$
$%3$®®®®®®®®®®®®®®®®®C=®®®®®®®®®A¦®®®®®®®®®®®®®®®M*®®®®®®®®!!®®®®®®®®®®($®®¦C®®®®®®®®®®®®®®®®®®33J3$
%$$%M®®®®®®®®®®®®®®®®C=®®®®®®®®®A¦®®!¦¦((!M®®®®®®M*®®®®®!!¦@®®®®®®®®®®¦%®®®®¦C®®®®®®®®®®®®®®®®®33J33
$$3%®®®®®®®®®®®®®®®®®C=®®®®®®®®®5¦®®®®®®®®®®®®®®®M!®®®®®®¦!®®®®®®®®®®!C®®®®®®((®®®®®®®®®®®®®®®®33J33
%$3%M®®®®®®®®®®®®®®®®C=®®®®M((®®5¦JJJJJJJJ@®®!!@®M*®®®®®®®=¦®®$!¦®®5!C®®JJJJJJ(¦®®®®®®®®®®®®®®®33J3$
%%3$®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®33333
$%$$M®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®33J3$
%$3$M®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®33J33
$%$$M®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®33J3$
%$3$M®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®®33J33
%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%
%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%
%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%
**/
